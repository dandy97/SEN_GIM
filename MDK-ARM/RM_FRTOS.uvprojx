# Keil uVision project RM_FRTOS.uvprojx, settings and files
target RM_FRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: RM_FRTOS
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F407xx,USE_HAL_DRIVER,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_M
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;..\user\led;..\user\can;..\user\can_receive;..\user\usart1;..\user\start_task;..\user\chassis_task;..\user\pid;..\user\rc;..\user\user_lib;..\user\DSP;..\user\DSP\Include;..\user\user_task;..\user\gimbal_task;..\user\gyro_task;..\user\shoot;..\user\auto_shoot;..\user\judg_info;..\user\ramp;..\user\fric;..\user\kalman
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_adc.c stm32f4xx_hal_pcd.c stm32f4xx_ll_usb.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_spi.c stm32f4xx_hal_gpio.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: queue.c timers.c event_groups.c croutine.c tasks.c list.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/User
    ../Src/: main.c stm32f4xx_it.c freertos.c
  group user_lib
    ../user/user_lib/: user_lib.c
    ../user/kalman/: kalman_filter.c
  group hardware
    ../user/led/: led.c
    ../user/can/: can.c
    ../user/usart1/: usart1.c
    ../user/rc/: rc.c
    ../user/auto_shoot/: auto_shoot.c
    ../user/judg_info/: judg_info.c
  group APP
    ../user/can_receive/: can_receive.c
    ../user/start_task/: start_task.c
    ../user/chassis_task/: chassis_task.c
    ../user/pid/: pid.c
    ../user/user_task/: user_task.c
    ../user/gimbal_task/: gimbal_task.c
software components: CMSIS:CORE 4.3.0
